# Keil uVision project Projekt.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Projekt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: .;.\libraries\StdPeriph;.\libraries\CMSIS;.\inc;.\utilities
  asm include: .;.\libraries\StdPeriph;.\libraries\CMSIS;.\inc;.\utilities
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group UserCode
    ./src/: main.c moje.c stm32f4xx_it.c libPDMFilter_Keil.lib kod.c
    ./libraries/: arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group StdPeriph
    ./libraries/StdPeriph/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c
  group CMSIS
    ./src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f40xx.s
